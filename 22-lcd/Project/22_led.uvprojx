# Keil uVision project 22_led.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lcd +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\bsp;..\User\bsp\inc;..\User\system;..\User\fonts
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
  group BSP
    ../User/bsp/: bsp.c bsp.h
    ../User/bsp/src/: bsp_led.c bsp_timer.c bsp_beep.c bsp_key.c bsp_uart.c bsp_iwdg.c bsp_wwdg.c bsp_tim_pwm.c bsp_tpad.c bsp_adc.c bsp_dac.c bsp_24cxx.c bsp_i2c_gpio.c bsp_nt35310_lcd.c
    ../User/bsp/inc/: bsp_led.h bsp_beep.h bsp_key.h bsp_uart.h bsp_iwdg.h bsp_wwdg.h bsp_tim_pwm.h bsp_tpad.h bsp_adc.h bsp_dac.h bsp_24cxx.h bsp_i2c_gpio.h bsp_nt35310_lcd.h
    ../User/fonts/: font.h
  group SYSTEM
    ../User/system/: stm32f10x_assert.c stm32f10x_it.c sys.h
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_fsmc.c
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_adc.h stm32f10x_fsmc.h
